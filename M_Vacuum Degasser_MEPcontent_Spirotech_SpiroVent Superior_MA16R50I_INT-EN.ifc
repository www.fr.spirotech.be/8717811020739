Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: M_Vacuum Degasser_MEPcontent_Spirotech_SpiroVent Superior_MA16R50I_INT-EN.ifc
Time: 2025-08-05T18:31:41+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcBuildingElementProxy: M_Vacuum Degasser_MEPcontent_Spirotech_SpiroVent Superior_S16A-R_INT-EN:MA16R50I, M_Vacuum Degasser_MEPcontent_Spirotech_SpiroVent Superior_S16A-R_INT-EN:MA16R50I:2099971
In: F00
Type - Material: <Unnamed>, Color RGB 168-168-168, Color RGB 000-255-000, Color RGB 255-000-000
Type - Other - Category: Mechanical Equipment; Family Name: M_Vacuum Degasser_MEPcontent_Spirotech_SpiroVent Superior_S16A-R_INT-EN
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Connection Diameter: 19.05 mm; Connection Nominal Diameter: 19.05 mm; Connection Outer Diameter: 26.9 mm; Depth: 400 mm; Height: 1272 mm; Use Nominal Diameter: yes; Width: 744 mm
Type - Electrical - Loads - Power: 2250 W; Voltage: 400 V
Type - Identity Data - Article Description: Vacuum degasser S16 - 9-16 bar - Refill - Insulated; Article Type: MA16R50I; Base Family Version: 25.09; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Vacuum degasser S16 - 9-16 bar - Refill - Insulated; EMCS Version: 4.0; ETIM Article Class: EC010260; Family Version: 12.30; GLN: 8717811000007; GTIN: 8717811020739; Manufacturer: Spirotech; Manufacturer Art. No.: MA16R50I; Manufacturer URL: https://www.spirotech.com/8717811020739; MEPcontent Class: VACUUM_DEGASSER; Model: MA16R50I; OmniClass Number: 23.75.50.11.14.14; OmniClass Title: Deaerators; Product Line: Spirotech; Revit Version: 2023; Type Name: MA16R50I; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Button: Color RGB 000-255-000; Equipment: Color RGB 168-168-168; Power Button: Color RGB 255-000-000
Type - Mechanical - Maximum Glycol (%): 40; Maximum Installation Volume: 0.3 m3; Temperature Range (°C): 0 - 90; Weight: 92 kg
Type - Mechanical - Loads - Workload: 16 Pa
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_BuildingElementProxyCommon - Reference: MA16R50I; IsExternal: no
Pset_EnvironmentalImpactIndicators - Reference: MA16R50I
Other - Family: M_Vacuum Degasser_MEPcontent_Spirotech_SpiroVent Superior_S16A-R_INT-EN; Family and Type: M_Vacuum Degasser_MEPcontent_Spirotech_SpiroVent Superior_S16A-R_INT-EN: MA16R50I; Left Clearance Safe: 600 mm; Right Clearance Safe: 600 mm; Type: MA16R50I; Type Id: 2099954
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 5.02487 m2; Volume: 0.379589 m3
Electrical - Loads - Apparent Load: 50 W
Identity Data - Mark: 4
Mechanical - System Classification: Hydronic Return,Power,Domestic Cold Water
Mechanical - Flow - Flow In: 0 m3/s; Flow In Cold Water: 0 m3/s; Flow Out: 0 m3/s
Phasing - Phase Created: 3. New Construction
Visibility - Left Clearance: 600 mm; Right Clearance: 600 mm; Show Service Area: no

# IfcDistributionPort (4)
Description: Flow
Name | FlowDirection | PredefinedType | SystemType
InPort_2099971_1 | SINK | PIPE | HEATING
OutPort_2099971_2 | SOURCE | PIPE | HEATING
Port_2099971_3 | SOURCEANDSINK | CABLE | ELECTRICAL
InPort_2099971_4 | SINK | PIPE | DOMESTICCOLDWATER
